# Keil uVision project project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARM_Comliler_5.06)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F407,__TARGET_FPU_VFP
  c include: ..\..\app;..\..\bsp;..\..\libraries\CMSIS\GD\GD32F4xx\Include;..\..\libraries\CMSIS\GD\GD32F4xx;..\..\libraries\GD32F4xx_standard_peripheral\Include;..\..\libraries\CMSIS;..\..\libraries\CMSIS\GD\GD32F4xx\Source\ARM;..\..\board;..\..\module\soft_timer;..\..\module\ringbuffer;..\..\module\buzzer;..\..\bsp\uart;..\..\bsp\OLED;..\..\bsp\FreeRTOS\include;..\..\bsp\FreeRTOS\portable\Keil;..\..\bsp\FreeRTOS\portable\MemMang;..\..\bsp\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\bsp\FreeRTOS;..\..\bsp\lvgl;..\..\bsp\lvgl\src;..\..\bsp\lvgl\examples\porting;..\..\bsp\lvgl\src\hal;..\..\bsp\lvgl\src\core;..\..\bsp\lvgl\demos\benchmark;..\..\bsp\lvgl\demos\benchmark\assets;..\..\bsp\easylogger\inc;..\..\bsp\LCD;..\..\bsp\SPI;..\..\bsp\TOUCH;..\..\bsp\lvgl\demos\keypad_encoder;..\..\bsp\lvgl\demos\widgets;..\..\bsp\lvgl\demos\widgets\assets
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\project.sct
  group APP
    ../../app/: main.c
  group STD_Driver
    ../../libraries/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group STARTUP
    ../../libraries/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group MODULE
    ../../module/soft_timer/: soft_timer.c
    ../../module/ringbuffer/: ringbuffer.c
  group CMSIS
    ../../libraries/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Board
    ../../board/: board.c
  group BSP
    ../../bsp/uart/: bsp_uart.c
    ../../bsp/TOUCH/: touch.c
    ../../bsp/SPI/: SPI.c
    ../../bsp/LCD/: lcd.c
  group DOC
    ../../: README.md
  group FreeRTOS
    ../../bsp/FreeRTOS/: FreeRTOSConfig.h croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../bsp/FreeRTOS/portable/MemMang/: heap_4.c
    ../../bsp/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group lvgl/config
    ../../bsp/lvgl/: lvgl.h lv_conf.h
  group lvgl/src
    ../../bsp/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../bsp/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../../bsp/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../../bsp/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../../bsp/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../../bsp/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../../bsp/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../bsp/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../bsp/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../../bsp/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../bsp/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../bsp/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../bsp/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../../bsp/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../bsp/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../../bsp/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../bsp/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../bsp/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../../bsp/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../bsp/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../../bsp/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../bsp/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../../bsp/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../bsp/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../../bsp/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../../bsp/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../../bsp/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../../bsp/lvgl/src/extra/others/msg/: lv_msg.c
    ../../bsp/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../bsp/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../bsp/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../bsp/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../bsp/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../bsp/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../bsp/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../bsp/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../bsp/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../bsp/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../bsp/lvgl/src/extra/widgets/led/: lv_led.c
    ../../bsp/lvgl/src/extra/widgets/list/: lv_list.c
    ../../bsp/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../bsp/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../bsp/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../bsp/lvgl/src/extra/widgets/span/: lv_span.c
    ../../bsp/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../bsp/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../bsp/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../bsp/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../bsp/lvgl/src/extra/widgets/win/: lv_win.c
    ../../bsp/lvgl/src/extra/: lv_extra.c
    ../../bsp/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../bsp/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../bsp/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../bsp/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lvgl/port
    ../../bsp/lvgl/examples/porting/: lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h
  group lvgl/demo
    ../../bsp/lvgl/demos/widgets/: lv_demo_widgets.c
    ../../bsp/lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
  group easylogger
    ../../bsp/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../../bsp/easylogger/port/: elog_port.c
